# Keil uVision project iSO-STM32.uvprojx, settings and files
target RA8875_emWin526_uCOSIII (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\emWin526\Config;..\..\emWin526\inc;..\..\User\Bsp\lcd;..\..\User\Bsp\sram;..\..\User\Bsp\touch;..\..\User\Bsp\usart;..\..\User\Bsp;..\..\User\OS;..\..\User\App;..\..\uCOSIII\uC-CPU;..\..\uCOSIII\uC-LIB;..\..\uCOSIII\uCOS-III\Ports;..\..\uCOSIII\uCOS-III\Source;..\..\User\Bsp\led;..\..\User\Bsp\Key;..\..\ff10;..\..\User\Bsp\sdcard;..\..\User\Bsp\spi;..\..\User\Bsp\i2c;..\..\User\Bsp\rtc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h includes.h
  group App
    ../../User/App/: TouchDemo.c app.c app.h appicon.c LEDapp.c KEYapp.c SRAMapp.c CANapp.c EEPROMapp.c keypadapp.c pysearch.c ADCapp.c DS18B20app.c DHT11app.c Breathingapp.c Clockapp.c
  group Bsp
    ../../User/Bsp/lcd/: bsp_ra8875_lcd.c
    ../../User/Bsp/sram/: bsp_fsmc_sram.c
    ../../User/Bsp/touch/: bsp_i2c_gpio.c gt9xx.c
    ../../User/Bsp/usart/: bsp_usart1.c
    ../../User/Bsp/: bsp.c
    ../../User/Bsp/led/: bsp_led.c
    ../../User/Bsp/Key/: key.c
    ../../User/Bsp/sdcard/: bsp_sdio_sdcard.c
    ../../User/Bsp/spi/: fatfs_flash_spi.c
    ../../User/Bsp/i2c/: bsp_i2c_ee.c bsp_i2c_gpio_ee.c
    ../../User/Bsp/rtc/: bsp_calendar.c bsp_date.c bsp_rtc.c
  group OS_Cfg
    ../../User/OS/: app_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group emWin526
    ../../emWin526/Config/: GUIConf.c GUIConf.h LCDConf_FlexColor_Template.c LCDConf_FlexColor_Template.h
    ../../emWin526/OS/: GUI_X_uCOS.c GUI_UC_EncodeNone.c GUICharPEx.c SimSun_12.c SimSun_16.c SimSun_24.c SimSun_32.c
    ../../emWin526/Lib/: STemWin526_CM3_OS_Keil.lib
  group uCOS_Ports
    ../../uCOSIII/uCOS-III/Ports/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group uCOS_Source
    ../../uCOSIII/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uCOS_CPU
    ../../uCOSIII/uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_core.c cpu_core.h cpu_def.h
  group uCOS_LIB
    ../../uCOSIII/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_mem_a.asm lib_str.c lib_str.h
  group ff10
    ../../ff10/: diskio.c ff.c firecc936.c
software components: CMSIS:CORE 5.0.1
